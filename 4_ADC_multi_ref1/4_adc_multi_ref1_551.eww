<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\4_adc_multi_ref1_551.ewp</path>
  </project>
  <batchBuild/>
</workspace>


