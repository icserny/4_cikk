<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adc_simple_ref2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


