<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\4_adc_multi2_ref1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


