<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\4_adc_simple_ref1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


